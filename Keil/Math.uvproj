# Keil uVision project Math.uvproj, settings and files
target Math_LB (ARM-ADS)
  device: NUC140VE3CN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Math_LB
  c flags: Optim=1
  c include: ..\;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\CMSIS\Include;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Device\Nuvoton\NUC100Series\Source;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Device\Nuvoton\NUC100Series\Source\ARM;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Device\Nuvoton\NUC100Series;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Nu-LB-NUC140\Source;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Nu-LB-NUC140\Include;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\StdDriver\src;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\StdDriver\inc;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Device\Nuvoton\NUC100Series\Include;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Nu-LB-NUC140\Include;B:\Aslab_Digital\Novuton\Nu-LB-NUC140_BSP3.00.004_v1.2\Library\Nu-LB-NUC140\Source;..\..\Math_LB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC100Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS Group
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/CMSIS/Include/: core_cm0.c
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group Source Group
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/Nu-LB-NUC140/Source/: LCD.c
    ../: main.c
  group Library Group
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/StdDriver/src/: gpio.c sys.c spi.c clk.c pwm.c
    B:/Aslab_Digital/Novuton/Nu-LB-NUC140_BSP3.00.004_v1.2/Library/Nu-LB-NUC140/Source/: SYS_init.c Scankey.c Draw2D.c
